** sch_path: xschem/Mixing_TB.sch
**.subckt Mixing_TB
V4 GND Vss 2.5
V3 Vdd GND 2.5
V1 Vref GND PULSE(-2.5 2.5 1n 1n 1n 0.5m 1m)
x12 Vdd Vref Vss Voutp Vinp Voutn Vinn PasMix
[
if {[sim_is_ngspice]} {
return {R3 Voutn GND 50k noisy=1 m=1 }
} else {
return {R3 Voutn GND 50k m=1 }
}
]
[
if {[sim_is_ngspice]} {
return {R1 Voutp GND 50k noisy=1 m=1 }
} else {
return {R1 Voutp GND 50k m=1 }
}
]
V2 Vinn GND TRNOISE(0 0.1u 1 25n)
V5 Vinp GND TRNOISE(0 0.1u 1 25n)
**** begin user architecture code
.lib $::SKYWATER_MODELS/sky130.lib.spice tt





.control
 *foreach val -0.2m -0.4m -0.6m -0.8m
  save all
  tran 0.1u 21m 1m
  let VO = 'v(Voutp) - v(Voutn)'
  let VI = 'v(Vinp) - v(Vinn)'
  let REF = 'v(Vref)'
  linearize VI VO REF
  set specwindow = blackman
  fft VI VO REF
  *let Freq = fourier11[0]
  *let Mag = fourier11[1]
  *noise v(vout+, vout-) V2 dec 100 1 30MEG
  *dc V2 -2.5 2.5 0.01
  *op
  write MIXER_FFT_NOISE.raw
  *let CM = $val
  *alterparam CM_VAL = $&CM
  set appendwrite
  reset
 *end
.endc
.end


**** end user architecture code
**.ends

* expanding   symbol:  PasMix.sym # of pins=7
** sym_path: xschem/PasMix.sym
** sch_path: xschem/PasMix.sch
.subckt PasMix Vdd V_cntrl Vss V_out1 V_in1 V_out2 Vin_2
*.ipin V_in1
*.ipin Vin_2
*.opin V_out1
*.opin V_out2
*.ipin Vdd
*.ipin Vss
*.ipin V_cntrl
x1 V_Invert V_in1 V_out1 Vdd Vss V_CLK T-gate
x2 V_Invert Vin_2 V_out2 Vdd Vss V_CLK T-gate
x3 V_CLK Vin_2 V_out1 Vdd Vss V_Invert T-gate
x4 V_CLK V_in1 V_out2 Vdd Vss V_Invert T-gate
XM3 net1 V_cntrl Vss Vss sky130_fd_pr__nfet_g5v0d10v5 L=1 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM4 net1 V_cntrl Vdd Vdd sky130_fd_pr__pfet_g5v0d10v5 L=1 W=3 nf=1 ad='int((1 + 1)/2) * 3 / 1 * 0.29'
+ as='int((1 + 2)/2) * 3 / 1 * 0.29' pd='2*int((1 + 1)/2) * (3 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (3 / 1 + 0.29)'
+ nrd='0.29 / 3 ' nrs='0.29 / 3 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5 V_CLK net1 Vss Vss sky130_fd_pr__nfet_g5v0d10v5 L=1 W=3 nf=1 ad='int((1 + 1)/2) * 3 / 1 * 0.29' as='int((1 + 2)/2) * 3 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (3 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (3 / 1 + 0.29)' nrd='0.29 / 3 ' nrs='0.29 / 3 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM6 V_CLK net1 Vdd Vdd sky130_fd_pr__pfet_g5v0d10v5 L=1 W=27 nf=1 ad='int((1 + 1)/2) * 27 / 1 * 0.29'
+ as='int((1 + 2)/2) * 27 / 1 * 0.29' pd='2*int((1 + 1)/2) * (27 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (27 / 1 + 0.29)'
+ nrd='0.29 / 27 ' nrs='0.29 / 27 ' sa=0 sb=0 sd=0 mult=1 m=1
XM7 net2 net1 Vss Vss sky130_fd_pr__nfet_g5v0d10v5 L=1 W=3 nf=1 ad='int((1 + 1)/2) * 3 / 1 * 0.29' as='int((1 + 2)/2) * 3 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (3 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (3 / 1 + 0.29)' nrd='0.29 / 3 ' nrs='0.29 / 3 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM8 net2 net1 Vdd Vdd sky130_fd_pr__pfet_g5v0d10v5 L=1 W=27 nf=1 ad='int((1 + 1)/2) * 27 / 1 * 0.29'
+ as='int((1 + 2)/2) * 27 / 1 * 0.29' pd='2*int((1 + 1)/2) * (27 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (27 / 1 + 0.29)'
+ nrd='0.29 / 27 ' nrs='0.29 / 27 ' sa=0 sb=0 sd=0 mult=1 m=1
XM9 V_Invert net2 Vss Vss sky130_fd_pr__nfet_g5v0d10v5 L=1 W=3 nf=1 ad='int((1 + 1)/2) * 3 / 1 * 0.29'
+ as='int((1 + 2)/2) * 3 / 1 * 0.29' pd='2*int((1 + 1)/2) * (3 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (3 / 1 + 0.29)'
+ nrd='0.29 / 3 ' nrs='0.29 / 3 ' sa=0 sb=0 sd=0 mult=1 m=1
XM10 V_Invert net2 Vdd Vdd sky130_fd_pr__pfet_g5v0d10v5 L=1 W=27 nf=1 ad='int((1 + 1)/2) * 27 / 1 * 0.29'
+ as='int((1 + 2)/2) * 27 / 1 * 0.29' pd='2*int((1 + 1)/2) * (27 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (27 / 1 + 0.29)'
+ nrd='0.29 / 27 ' nrs='0.29 / 27 ' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  T-gate.sym # of pins=6
** sym_path: xschem/T-gate.sym
** sch_path: xschem/T-gate.sch
.subckt T-gate I_CLK T_In T_Out Vdd Vss CLK
*.ipin T_In
*.opin T_Out
*.ipin Vdd
*.ipin Vss
*.ipin I_CLK
*.ipin CLK
XM1 T_In I_CLK T_Out Vdd sky130_fd_pr__pfet_g5v0d10v5 L=0.5 W=3 nf=1 ad='int((1 + 1)/2) * 3 / 1 * 0.29'
+ as='int((1 + 2)/2) * 3 / 1 * 0.29' pd='2*int((1 + 1)/2) * (3 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (3 / 1 + 0.29)'
+ nrd='0.29 / 3 ' nrs='0.29 / 3 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3 T_Out CLK T_In Vss sky130_fd_pr__nfet_g5v0d10v5 L=0.5 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM2 T_Out CLK T_Out Vdd sky130_fd_pr__pfet_g5v0d10v5 L=0.5 W=1.5 nf=1 ad='int((1 + 1)/2) * 1.5 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1.5 / 1 + 0.29)'
+ nrd='0.29 / 1.5 ' nrs='0.29 / 1.5 ' sa=0 sb=0 sd=0 mult=1 m=1
XM4 T_In CLK T_In Vdd sky130_fd_pr__pfet_g5v0d10v5 L=0.5 W=1.5 nf=1 ad='int((1 + 1)/2) * 1.5 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1.5 / 1 + 0.29)'
+ nrd='0.29 / 1.5 ' nrs='0.29 / 1.5 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5 T_In I_CLK T_In Vss sky130_fd_pr__nfet_g5v0d10v5 L=0.5 W=0.5 nf=1 ad='int((1 + 1)/2) * 0.5 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.5 / 1 + 0.29)'
+ nrd='0.29 / 0.5 ' nrs='0.29 / 0.5 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6 T_Out I_CLK T_Out Vss sky130_fd_pr__nfet_g5v0d10v5 L=0.5 W=0.5 nf=1 ad='int((1 + 1)/2) * 0.5 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.5 / 1 + 0.29)'
+ nrd='0.29 / 0.5 ' nrs='0.29 / 0.5 ' sa=0 sb=0 sd=0 mult=1 m=1
.ends

.GLOBAL GND
.end
