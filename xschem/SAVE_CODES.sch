v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
B 2 -3705 -552.5 -2096.25 102.5 {flags=graph
y1=-12.358933
y2=92.089066
ypos1=0
ypos2=0.01
subdivy=4
unity=1
x1=-3.1192805
x2=5.3578408
divx=10
subdivx=8
xlabmag=1.0
ylabmag=1.0
unitx=1
logx=1
logy=0
rainbow=1
divy=10
hilight_wave=0
sim_type=ac
digital=0
mode=Line
color=17
node="\\"AC Diff Phase FF; ph(voutp)\\""
sweep=" "
hcursor1_y=-114.73835
dataset=-1}
B 2 -3706.25 -1167.5 -2096.25 -557.5 {flags=graph
y1=-21.634409
y2=70.265591
ypos1=0
ypos2=2
divy=10
subdivy=5
unity=1
x1=-3.1192805
x2=5.3578408
subdivx=8
xlabmag=1.0
ylabmag=1.0
unitx=1
logx=1
logy=0
sim_type=ac
rainbow=1
hilight_wave=-1
color=10
node="\\"AC Diff Gain dB FF; voutp voutm + 2 / db20()\\""
mode=Line
hcursor2_y=-215.57495
sweep=" "
divx=10
hcursor1_y=-0.081200336
dataset=-1}
N -1010 -1170 -990 -1170 {lab=Vdd}
N -690 -1170 -670 -1170 {lab=Vbiasp}
N -370 -1170 -370 -1050 {lab=Vbiasp}
N -440 -1120 -440 -1080 {lab=Vdd}
N -440 -940 -440 -910 {lab=Vss}
N -530 -1040 -480 -1040 {lab=#net1}
N -310 -1010 -270 -1010 {lab=Vout}
N -270 -1010 -220 -1010 {lab=Vout}
N -220 -1010 -200 -1010 {lab=Vout}
N -590 -1040 -530 -1040 {lab=#net1}
N -520 -1170 -460 -1170 {lab=Vbiasp}
N -460 -1170 -400 -1170 {lab=Vbiasp}
N -400 -1170 -370 -1170 {lab=Vbiasp}
N -670 -1170 -520 -1170 {lab=Vbiasp}
N -1010 -1150 -990 -1150 {lab=PWRDWN}
N -370 -1170 -290 -1170 {lab=Vbiasp}
N -400 -860 -240 -860 {lab=Vout}
N -530 -860 -460 -860 {lab=#net2}
N -740 -1040 -690 -1040 {lab=Vin+}
N -240 -900 -240 -860 {lab=Vout}
N -240 -1010 -240 -960 {lab=Vout}
N -630 -1040 -590 -1040 {lab=#net1}
N -530 -980 -480 -980 {lab=#net3}
N -750 -850 -700 -850 {lab=Vin-}
N -530 -770 -530 -730 {lab=GND}
N -720 -1040 -720 -1010 {lab=Vin+}
N -720 -950 -720 -910 {lab=GND}
N -720 -850 -720 -820 {lab=Vin-}
N -720 -760 -720 -720 {lab=GND}
N -640 -850 -590 -850 {lab=#net3}
N -590 -980 -590 -850 {lab=#net3}
N -590 -980 -530 -980 {lab=#net3}
N -530 -900 -530 -860 {lab=#net2}
N -530 -980 -530 -960 {lab=#net3}
N -240 -960 -240 -900 {lab=Vout}
N -610 -920 -610 -880 {lab=GND}
N -610 -960 -610 -920 {lab=GND}
N -610 -1040 -610 -1020 {lab=#net1}
N -530 -860 -530 -830 {lab=#net2}
N -280 -1010 -280 -980 {lab=Vout}
N -280 -920 -280 -880 {lab=GND}
N -500 -1640 -500 -1620 {lab=Vdd}
N -500 -1480 -500 -1460 {lab=Vss}
N -560 -1680 -510 -1680 {lab=#net4}
N -560 -1420 -510 -1420 {lab=#net5}
N -700 -1570 -640 -1570 {lab=#net5}
N -940 -1660 -920 -1660 {lab=Vdd}
N -620 -1660 -600 -1660 {lab=#net6}
N -270 -1550 -240 -1550 {lab=VCM}
N -600 -1660 -460 -1660 {lab=#net6}
N -180 -1650 -180 -1630 {lab=Vdd}
N -180 -1470 -180 -1450 {lab=Vss}
N -740 -1540 -740 -1380 {lab=Vbias-}
N -740 -1550 -740 -1540 {lab=Vbias-}
N -370 -1420 -350 -1420 {lab=Vout-}
N -460 -1660 -330 -1660 {lab=#net6}
N -200 -1470 -200 -1430 {lab=#net6}
N -200 -1430 -80 -1430 {lab=#net6}
N -80 -1660 -80 -1430 {lab=#net6}
N -330 -1660 -80 -1660 {lab=#net6}
N -380 -1560 -350 -1560 {lab=Vout+}
N -370 -1680 -350 -1680 {lab=Vout+}
N -350 -1680 -350 -1630 {lab=Vout+}
N -350 -1480 -350 -1420 {lab=Vout-}
N -350 -1630 -350 -1570 {lab=Vout+}
N -350 -1570 -350 -1560 {lab=Vout+}
N -350 -1640 -320 -1640 {lab=Vout+}
N -350 -1450 -310 -1450 {lab=Vout-}
N -480 -1660 -480 -1610 {lab=#net6}
N -580 -1570 -540 -1570 {lab=#net5}
N -580 -1530 -540 -1530 {lab=#net4}
N -740 -1550 -540 -1550 {lab=Vbias-}
N -390 -1560 -380 -1560 {lab=Vout+}
N -390 -1540 -380 -1540 {lab=Vout-}
N -380 -1540 -350 -1540 {lab=Vout-}
N -350 -1540 -350 -1480 {lab=Vout-}
N -100 -1380 -70 -1380 {lab=Vbias-}
N -70 -1380 -60 -1380 {lab=Vbias-}
N -450 -1680 -430 -1680 {lab=#net7}
N -450 -1420 -430 -1420 {lab=#net8}
N -60 -1410 -60 -1380 {lab=Vbias-}
N -60 -1510 -60 -1470 {lab=Vbias-}
N -60 -1520 -60 -1510 {lab=Vbias-}
N -160 -1380 -100 -1380 {lab=Vbias-}
N -60 -1470 -60 -1410 {lab=Vbias-}
N -700 -1530 -640 -1530 {lab=#net4}
N -740 -1380 -220 -1380 {lab=Vbias-}
N -220 -1380 -160 -1380 {lab=Vbias-}
N -570 -1420 -560 -1420 {lab=#net5}
N -120 -1520 -20 -1520 {lab=Vbias-}
N -570 -1570 -570 -1420 {lab=#net5}
N -560 -1680 -560 -1530 {lab=#net4}
N -120 -1570 -20 -1570 {lab=Vbias+}
N -790 -1570 -760 -1570 {lab=Vin+}
N -800 -1530 -770 -1530 {lab=Vin-}
N -690 -1570 -690 -1560 {lab=#net5}
N -350 -1580 -330 -1580 {lab=Vout+}
N -270 -1580 -240 -1580 {lab=Vout+}
N -350 -1520 -330 -1520 {lab=Vout-}
N -270 -1520 -240 -1520 {lab=Vout-}
N -330 -1580 -270 -1580 {lab=Vout+}
N -330 -1520 -270 -1520 {lab=Vout-}
N -710 -1530 -700 -1530 {lab=#net4}
N -950 -1640 -920 -1640 {lab=PWRDWN}
N -780 -1530 -780 -1500 {lab=Vin-}
N -780 -1440 -780 -1410 {lab=GND}
N -910 -1580 -910 -1550 {lab=Vin+}
N -910 -1490 -910 -1460 {lab=GND}
N -910 -1600 -910 -1580 {lab=Vin+}
N -910 -1600 -780 -1600 {lab=Vin+}
N -780 -1600 -780 -1570 {lab=Vin+}
N -440 -1710 -440 -1680 {lab=#net7}
N -440 -1300 -440 -1270 {lab=GND}
N -440 -1800 -440 -1770 {lab=GND}
N -640 -1570 -580 -1570 {lab=#net5}
N -640 -1530 -580 -1530 {lab=#net4}
N -440 -1420 -440 -1360 {lab=#net8}
N -350 -1680 -260 -1680 {lab=Vout+}
N -200 -1680 -170 -1680 {lab=GND}
N -350 -1420 -260 -1420 {lab=Vout-}
N -200 -1420 -170 -1420 {lab=GND}
N -3030 -1840 -3010 -1840 {lab=Vdd}
N -2710 -1840 -2690 -1840 {lab=#net9}
N -2510 -1830 -2510 -1790 {lab=Vdd}
N -2510 -1610 -2510 -1580 {lab=Vss}
N -2620 -1730 -2580 -1730 {lab=Vin+}
N -2690 -1840 -2690 -1700 {lab=#net9}
N -2690 -1700 -2580 -1700 {lab=#net9}
N -3000 -1700 -2970 -1700 {lab=#net10}
N -3090 -1700 -3060 -1700 {lab=GND}
N -2970 -1760 -2950 -1760 {lab=#net10}
N -2720 -1760 -2660 -1760 {lab=Vin+}
N -2660 -1760 -2660 -1730 {lab=Vin+}
N -2660 -1730 -2620 -1730 {lab=Vin+}
N -2890 -1760 -2860 -1760 {lab=Vg+}
N -2750 -1760 -2720 -1760 {lab=Vin+}
N -2630 -1670 -2580 -1670 {lab=Voutb}
N -2740 -1760 -2740 -1730 {lab=Vin+}
N -2740 -1670 -2740 -1650 {lab=GND}
N -2660 -1670 -2630 -1670 {lab=Voutb}
N -2660 -1670 -2660 -1660 {lab=Voutb}
N -2660 -1660 -2660 -1650 {lab=Voutb}
N -2740 -1650 -2740 -1610 {lab=GND}
N -2360 -1580 -2360 -1550 {lab=GND}
N -2360 -1670 -2360 -1640 {lab=#net11}
N -2970 -1760 -2970 -1700 {lab=#net10}
N -2890 -1620 -2840 -1620 {lab=Vg-}
N -2460 -1670 -2420 -1670 {lab=#net11}
N -2460 -1730 -2430 -1730 {lab=GND}
N -2600 -1760 -2580 -1760 {lab=Vg+}
N -2600 -1640 -2580 -1640 {lab=Vg-}
N -2970 -1700 -2970 -1620 {lab=#net10}
N -2970 -1620 -2950 -1620 {lab=#net10}
N -2420 -1670 -2410 -1670 {lab=#net11}
N -2410 -1670 -2370 -1670 {lab=#net11}
N -2090 -1810 -2090 -1770 {lab=Vdd}
N -2090 -1590 -2090 -1560 {lab=Vss}
N -2200 -1710 -2160 -1710 {lab=#net11}
N -2270 -1680 -2160 -1680 {lab=#net9}
N -2210 -1650 -2160 -1650 {lab=Voutb}
N -2040 -1650 -2000 -1650 {lab=Voutb}
N -2040 -1710 -2010 -1710 {lab=GND}
N -2180 -1740 -2160 -1740 {lab=Vg+}
N -2180 -1620 -2160 -1620 {lab=Vg-}
N -2240 -1520 -1990 -1520 {lab=Voutb}
N -1990 -1650 -1990 -1520 {lab=Voutb}
N -2000 -1650 -1990 -1650 {lab=Voutb}
N -1990 -1650 -1950 -1650 {lab=Voutb}
N -2690 -1840 -2280 -1840 {lab=#net9}
N -2280 -1840 -2280 -1680 {lab=#net9}
N -2280 -1680 -2270 -1680 {lab=#net9}
N -2370 -1670 -2200 -1670 {lab=#net11}
N -2200 -1710 -2200 -1670 {lab=#net11}
N -2660 -1520 -2240 -1520 {lab=Voutb}
N -2660 -1550 -2660 -1520 {lab=Voutb}
N -2210 -1650 -2210 -1520 {lab=Voutb}
N -2660 -1650 -2660 -1550 {lab=Voutb}
N -2660 -1430 -2660 -1400 {lab=GND}
N -2660 -1520 -2660 -1490 {lab=Voutb}
N -4982.5 -407.5 -4982.5 -377.5 {lab=VCM}
N -4982.5 -317.5 -4982.5 -287.5 {lab=GND}
N -5052.5 -407.5 -5052.5 -377.5 {lab=VoCM}
N -5052.5 -317.5 -5052.5 -287.5 {lab=GND}
N -4872.5 -967.5 -4872.5 -937.5 {lab=Vin-}
N -4872.5 -777.5 -4872.5 -747.5 {lab=Vinp}
N -4872.5 -877.5 -4872.5 -847.5 {lab=GND}
N -4872.5 -687.5 -4872.5 -657.5 {lab=GND}
N -4732.5 -707.5 -4732.5 -657.5 {lab=GND}
N -4732.5 -827.5 -4732.5 -787.5 {lab=GND}
N -4732.5 -937.5 -4732.5 -917.5 {lab=Vdd}
N -4732.5 -597.5 -4732.5 -567.5 {lab=Vss}
N -4862.5 -597.5 -4862.5 -567.5 {lab=PWRDWN}
N -4862.5 -507.5 -4862.5 -477.5 {lab=GND}
N -4732.5 -917.5 -4732.5 -887.5 {lab=Vdd}
N -4732.5 -687.5 -4652.5 -687.5 {lab=GND}
N -4652.5 -687.5 -4652.5 -647.5 {lab=GND}
N -4652.5 -597.5 -4652.5 -577.5 {lab=Vss}
N -4732.5 -577.5 -4652.5 -577.5 {lab=Vss}
N -4732.5 -917.5 -4652.5 -917.5 {lab=Vdd}
N -4652.5 -917.5 -4652.5 -877.5 {lab=Vdd}
N -4652.5 -827.5 -4652.5 -807.5 {lab=GND}
N -4732.5 -807.5 -4652.5 -807.5 {lab=GND}
N -4382.5 -317.5 -4382.5 -297.5 {lab=Vdd}
N -4382.5 -157.5 -4382.5 -137.5 {lab=Vss}
N -4442.5 -357.5 -4392.5 -357.5 {lab=#net1}
N -4442.5 -97.5 -4392.5 -97.5 {lab=#net2}
N -4582.5 -247.5 -4522.5 -247.5 {lab=Vinp}
N -4822.5 -337.5 -4802.5 -337.5 {lab=Vdd}
N -4502.5 -337.5 -4482.5 -337.5 {lab=#net3}
N -4152.5 -227.5 -4122.5 -227.5 {lab=VCM}
N -4482.5 -337.5 -4342.5 -337.5 {lab=#net3}
N -4062.5 -327.5 -4062.5 -307.5 {lab=Vdd}
N -4062.5 -147.5 -4062.5 -127.5 {lab=Vss}
N -4622.5 -217.5 -4622.5 -57.5 {lab=Vbiasm}
N -4622.5 -227.5 -4622.5 -217.5 {lab=Vbiasm}
N -4252.5 -97.5 -4232.5 -97.5 {lab=Voutm}
N -4342.5 -337.5 -4212.5 -337.5 {lab=#net3}
N -4082.5 -147.5 -4082.5 -107.5 {lab=#net3}
N -4082.5 -107.5 -3962.5 -107.5 {lab=#net3}
N -3962.5 -337.5 -3962.5 -107.5 {lab=#net3}
N -4212.5 -337.5 -3962.5 -337.5 {lab=#net3}
N -4262.5 -237.5 -4232.5 -237.5 {lab=Voutp}
N -4252.5 -357.5 -4232.5 -357.5 {lab=Voutp}
N -4232.5 -357.5 -4232.5 -307.5 {lab=Voutp}
N -4232.5 -157.5 -4232.5 -97.5 {lab=Voutm}
N -4232.5 -307.5 -4232.5 -247.5 {lab=Voutp}
N -4232.5 -247.5 -4232.5 -237.5 {lab=Voutp}
N -4232.5 -317.5 -4202.5 -317.5 {lab=Voutp}
N -4232.5 -127.5 -4192.5 -127.5 {lab=Voutm}
N -4362.5 -337.5 -4362.5 -287.5 {lab=#net3}
N -4462.5 -247.5 -4422.5 -247.5 {lab=#net2}
N -4462.5 -207.5 -4422.5 -207.5 {lab=#net1}
N -4622.5 -227.5 -4422.5 -227.5 {lab=Vbiasm}
N -4272.5 -237.5 -4262.5 -237.5 {lab=Voutp}
N -4272.5 -217.5 -4262.5 -217.5 {lab=Voutm}
N -4262.5 -217.5 -4232.5 -217.5 {lab=Voutm}
N -4232.5 -217.5 -4232.5 -157.5 {lab=Voutm}
N -3982.5 -57.5 -3952.5 -57.5 {lab=Vbiasm}
N -3952.5 -57.5 -3942.5 -57.5 {lab=Vbiasm}
N -4332.5 -97.5 -4312.5 -97.5 {lab=#net2}
N -3942.5 -87.5 -3942.5 -57.5 {lab=Vbiasm}
N -3942.5 -187.5 -3942.5 -147.5 {lab=Vbiasm}
N -3942.5 -197.5 -3942.5 -187.5 {lab=Vbiasm}
N -4042.5 -57.5 -3982.5 -57.5 {lab=Vbiasm}
N -3942.5 -147.5 -3942.5 -87.5 {lab=Vbiasm}
N -4582.5 -207.5 -4522.5 -207.5 {lab=Vinm}
N -4622.5 -57.5 -4102.5 -57.5 {lab=Vbiasm}
N -4102.5 -57.5 -4042.5 -57.5 {lab=Vbiasm}
N -4452.5 -97.5 -4442.5 -97.5 {lab=#net2}
N -4002.5 -197.5 -3902.5 -197.5 {lab=Vbiasm}
N -4452.5 -247.5 -4452.5 -97.5 {lab=#net2}
N -4442.5 -357.5 -4442.5 -207.5 {lab=#net1}
N -4002.5 -247.5 -3902.5 -247.5 {lab=Vbiasp}
N -4572.5 -247.5 -4572.5 -237.5 {lab=Vinp}
N -4232.5 -257.5 -4212.5 -257.5 {lab=Voutp}
N -4152.5 -257.5 -4122.5 -257.5 {lab=#net4}
N -4232.5 -197.5 -4212.5 -197.5 {lab=Voutm}
N -4152.5 -197.5 -4122.5 -197.5 {lab=#net5}
N -4592.5 -207.5 -4582.5 -207.5 {lab=Vinm}
N -4832.5 -317.5 -4802.5 -317.5 {lab=PWRDWN}
N -4232.5 -357.5 -4142.5 -357.5 {lab=Voutp}
N -4082.5 -357.5 -4052.5 -357.5 {lab=GND}
N -4232.5 -97.5 -4142.5 -97.5 {lab=Voutm}
N -4082.5 -97.5 -4052.5 -97.5 {lab=GND}
N -4392.5 -97.5 -4332.5 -97.5 {lab=#net2}
N -4382.5 -357.5 -4312.5 -357.5 {lab=#net1}
N -4392.5 -357.5 -4382.5 -357.5 {lab=#net1}
N -4142.5 -157.5 -4122.5 -157.5 {lab=#net5}
N -4132.5 -197.5 -4132.5 -157.5 {lab=#net5}
N -4152.5 -287.5 -4132.5 -287.5 {lab=#net4}
N -4132.5 -287.5 -4132.5 -257.5 {lab=#net4}
N -4252.5 -287.5 -4212.5 -287.5 {lab=VoCM}
N -4222.5 -157.5 -4202.5 -157.5 {lab=VoCM}
N -4132.5 -287.5 -4122.5 -287.5 {lab=#net4}
C {code_shown.sym} -280 -250 0 0 {name=op_amp_3_test only_toplevel=false value="
.lib /foss/pdks/sky130A/libs.tech/combined/sky130.lib.spice tt
.control
  *dc V1 -2.5 2.5 0.01
  tran 1u 10m 
  *ac dec 100 0.1 30MEG
  *plot db(v(Vout)/(v(Vin+))) xlog title 'Gain BW'
  *plot (180/PI)*phase(v(Vout)/v(Vin+)) xlog title 'Phase BW'
  plot v(Vout)
  plot v(Vin+)
  *op
  *noise v(Vout) V1 dec 100 0.1 1MEG
.endc
.end"}
C {code_shown.sym} -977.5 -627.5 0 0 {name=s1 only_toplevel=false value="
.lib /foss/pdks/sky130A/libs.tech/combined/sky130.lib.spice tt_mm
.param ptemp = 27
.options temp = \{ptemp\}
.control
 *let T = 0
 *foreach val -20 0 27 80 100 120 140
  *tran 0.1u 8m
  save all
  *ID
  save @m.x1.xm1.msky130_fd_pr__pfet_g5v0d10v5[id]
  save @m.x1.xm2.msky130_fd_pr__pfet_g5v0d10v5[id]
  save @m.x1.xm3.msky130_fd_pr__nfet_g5v0d10v5[id]
  save @m.x1.xm4.msky130_fd_pr__nfet_g5v0d10v5[id]
  save @m.x1.xm5.msky130_fd_pr__pfet_g5v0d10v5[id]
  save @m.x1.xm6.msky130_fd_pr__pfet_g5v0d10v5[id]
  save @m.x1.xm7.msky130_fd_pr__pfet_g5v0d10v5[id]
  save @m.x1.xm8.msky130_fd_pr__nfet_g5v0d10v5[id]
  save @m.x1.xm9.msky130_fd_pr__pfet_g5v0d10v5[id]
  save @m.x1.xm10.msky130_fd_pr__nfet_g5v0d10v5[id]
  save @m.x1.xm11.msky130_fd_pr__nfet_g5v0d10v5[id]

 *Gm
  save @m.x1.xm1.msky130_fd_pr__pfet_g5v0d10v5[gm]
  save @m.x1.xm2.msky130_fd_pr__pfet_g5v0d10v5[gm]
  save @m.x1.xm3.msky130_fd_pr__nfet_g5v0d10v5[gm]
  save @m.x1.xm4.msky130_fd_pr__nfet_g5v0d10v5[gm]
  save @m.x1.xm5.msky130_fd_pr__pfet_g5v0d10v5[gm]
  save @m.x1.xm6.msky130_fd_pr__pfet_g5v0d10v5[gm]
  save @m.x1.xm7.msky130_fd_pr__pfet_g5v0d10v5[gm]
  save @m.x1.xm8.msky130_fd_pr__nfet_g5v0d10v5[gm]
  save @m.x1.xm9.msky130_fd_pr__pfet_g5v0d10v5[gm]
  save @m.x1.xm10.msky130_fd_pr__nfet_g5v0d10v5[gm]
  save @m.x1.xm11.msky130_fd_pr__nfet_g5v0d10v5[gm]

  op
  write OP_AMP_TB_OP_MM.raw
  set appendwrite
  *let T = $val
  *alterparam ptemp = $&T
  reset
 *end
.endc
.end"}
C {code_shown.sym} -1687.5 -517.5 0 0 {name=s2 only_toplevel=false value="
.lib /foss/pdks/sky130A/libs.tech/combined/sky130.lib.spice tt
.param ptemp = 27
.options temp = \{ptemp\}
.control
 *let T = 0
 *foreach val -20 0 27 80 100 120 140
  *tran 0.1u 8m
  save all
  ac dec 100 0.1 30MEG
  plot db(v(Vout)/(v(Vin+))) xlog title 'Gain BW'
  plot (180/PI)*phase(v(Vout)/v(Vin+)) xlog title 'Phase BW'
  write OP_AMP_AC.raw
  set appendwrite
  *let T = $val
  *alterparam ptemp = $&T
  reset
 *end
.endc
.end"}
C {BMR.sym} -840 -1160 0 0 {name=x2}
C {lab_pin.sym} -1010 -1170 3 1 {name=p2 lab=Vdd}
C {OP_AMP_PMOS_REVISE.sym} -410 -1010 0 0 {name=x1}
C {lab_pin.sym} -440 -1120 0 0 {name=p1 lab=Vdd}
C {lab_pin.sym} -440 -910 0 0 {name=p3 lab=Vss}
C {lab_pin.sym} -200 -1010 0 1 {name=p13 lab=Vout}
C {lab_pin.sym} -1010 -1150 0 0 {name=p10 lab=PWRDWN}
C {lab_pin.sym} -290 -1170 0 1 {name=p5 lab=Vbiasp}
C {gnd.sym} -530 -730 0 0 {name=l8 lab=GND}
C {lab_pin.sym} -740 -1040 0 0 {name=p11 lab=Vin+}
C {capa.sym} -660 -1040 3 1 {name=C3
m=1
value=1G
footprint=1206
device="ceramic capacitor"}
C {lab_pin.sym} -750 -850 0 0 {name=p4 lab=Vin-}
C {capa.sym} -670 -850 3 1 {name=C4
m=1
value=1G
footprint=1206
device="ceramic capacitor"}
C {res.sym} -430 -860 1 0 {name=R1
value=10k
footprint=1206
device=resistor
m=1}
C {res.sym} -720 -980 0 0 {name=R2
value=1G
footprint=1206
device=resistor
m=1}
C {gnd.sym} -720 -910 0 0 {name=l7 lab=GND}
C {res.sym} -720 -790 0 1 {name=R3
value=1G
footprint=1206
device=resistor
m=1}
C {gnd.sym} -720 -720 0 1 {name=l10 lab=GND}
C {ind.sym} -530 -930 2 0 {name=L11
m=1
value=1G
footprint=1206
device=inductor}
C {gnd.sym} -610 -880 0 0 {name=l6 lab=GND}
C {ind.sym} -610 -990 2 0 {name=L12
m=1
value=1G
footprint=1206
device=inductor}
C {res.sym} -530 -800 2 0 {name=R4
value=10k
footprint=1206
device=resistor
m=1}
C {capa.sym} -280 -950 0 0 {name=C5
m=1
value=\{C_VAL\}
footprint=1206
device="ceramic capacitor"}
C {gnd.sym} -280 -880 0 0 {name=l9 lab=GND}
C {Diff_OP_AMP.sym} -460 -1550 0 0 {name=x3}
C {lab_pin.sym} -500 -1640 0 0 {name=p6 lab=Vdd}
C {lab_pin.sym} -500 -1460 0 0 {name=p9 lab=Vss}
C {lab_pin.sym} -790 -1570 0 0 {name=p21 lab=Vin+}
C {BMR.sym} -770 -1650 0 0 {name=x4}
C {lab_pin.sym} -940 -1660 3 1 {name=p7 lab=Vdd}
C {CMFB.sym} -180 -1550 0 0 {name=x5}
C {lab_pin.sym} -180 -1450 2 0 {name=p8 lab=Vss}
C {lab_pin.sym} -180 -1650 0 1 {name=p12 lab=Vdd}
C {lab_pin.sym} -310 -1450 2 0 {name=p18 lab=Vout-}
C {lab_pin.sym} -320 -1640 0 1 {name=p19 lab=Vout+}
C {lab_pin.sym} -20 -1520 0 1 {name=p14 lab=Vbias-}
C {lab_pin.sym} -270 -1550 0 0 {name=p15 lab=VCM}
C {lab_pin.sym} -20 -1570 0 1 {name=p16 lab=Vbias+}
C {lab_pin.sym} -800 -1530 0 0 {name=p17 lab=Vin-}
C {res.sym} -400 -1420 3 1 {name=R5
value=10k
footprint=1206
device=resistor
m=1}
C {res.sym} -400 -1680 3 1 {name=R6
value=10k
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} -950 -1640 3 1 {name=p20 lab=PWRDWN}
C {ind.sym} -480 -1680 3 1 {name=L3
m=1
value=1T
footprint=1206
device=inductor}
C {ind.sym} -480 -1420 3 1 {name=L4
m=1
value=1T
footprint=1206
device=inductor}
C {capa.sym} -730 -1570 3 1 {name=C1
m=1
value=1G
footprint=1206
device="ceramic capacitor"}
C {capa.sym} -740 -1530 3 1 {name=C2
m=1
value=1G
footprint=1206
device="ceramic capacitor"}
C {res.sym} -780 -1470 0 1 {name=R7
value=1MEG
footprint=1206
device=resistor
m=1}
C {gnd.sym} -780 -1410 0 0 {name=l1 lab=GND}
C {res.sym} -910 -1520 0 1 {name=R8
value=1MEG
footprint=1206
device=resistor
m=1}
C {gnd.sym} -910 -1460 0 0 {name=l2 lab=GND}
C {res.sym} -440 -1740 0 1 {name=R9
value=10k
footprint=1206
device=resistor
m=1}
C {res.sym} -440 -1330 0 1 {name=R10
value=10k
footprint=1206
device=resistor
m=1}
C {gnd.sym} -440 -1270 0 0 {name=l5 lab=GND}
C {gnd.sym} -440 -1800 2 0 {name=l13 lab=GND}
C {capa.sym} -230 -1680 3 0 {name=C6
m=1
value=\{C_VAL\}
footprint=1206
device="ceramic capacitor"}
C {gnd.sym} -170 -1680 3 1 {name=l15 lab=GND}
C {capa.sym} -230 -1420 3 0 {name=C7
m=1
value=\{C_VAL\}
footprint=1206
device="ceramic capacitor"}
C {gnd.sym} -170 -1420 3 1 {name=l16 lab=GND}
C {code_shown.sym} 10 -760 0 0 {name=FDA only_toplevel=false value="
.param C_VAL = 0.5p
.lib /foss/pdks/sky130A/libs.tech/combined/sky130.lib.spice tt
.control
 foreach val 1p 1.5p 2p 2p
  save all
  *set nfreqs = 10
  *tran 1u 5m 1m
  *fourier 1k v(vout)
  ac dec 100 0.1 50MEG
  plot db((v(Vout+)- V(Vout-))/(v(Vin+))) xlog title 'Gain BW'
  plot (180/PI)*phase((v(Vout+)- V(Vout-))/v(Vin+)) xlog title 'Phase BW'
  plot (180/PI)*phase((v(Vout+)- V(Vout-))) xlog title 'Phase BW_T'
  let C = $val
  alterparam C_VAL = $&C
  write FDA_TB_AC.raw
  set appendwrite
  reset
 end
.endc
.end"}
C {code_shown.sym} -1790 -1490 0 0 {name=s3 only_toplevel=false value="
* gm/ID Characterization for Sky130 nfet_01v8
* Parameters
.lib /foss/pdks/sky130A/libs.tech/combined/sky130.lib.spice ss
.param setup = 0

.control
   
  * Direct Plotting in ngspice
 set xbrushwidth=2
 let s_val =2.1n
 set plot_set_up = ' '
 set plot_clk = ' '
 repeat 20
  alterparam setup = $&s_val
  reset
  tran 1p 3n
  let vq = 'v(Q)'
  let vclk = 'v(Vin)'
  set plot_set_up = ( $plot_set_up \{$curplot\}.vq )
  set plot_clk = ( $plot_clk \{$curplot\}.vclk )

  let s_val = s_val - 10p
 end
  set nolegend 
  plot $plot_set_up title 'Setup Time'
  plot $plot_clk v(clk_in) title 'Input and clk'
  
.endc
.end"}
C {vsource.sym} -2740 -1700 0 0 {name=V1 value="SINE(0 0.01 2kHz)" savecurrent=false}
C {lab_pin.sym} -2750 -1760 0 0 {name=p22 lab=Vin+}
C {lab_pin.sym} -3030 -1840 3 1 {name=p23 lab=Vdd}
C {lab_pin.sym} -2510 -1830 0 0 {name=p24 lab=Vdd}
C {lab_pin.sym} -2510 -1580 0 0 {name=p25 lab=Vss}
C {vsource.sym} -3030 -1700 3 1 {name=V5 value="dc 1.1" savecurrent=false}
C {vsource.sym} -2920 -1760 1 0 {name=V6 value="dc 0" savecurrent=false}
C {gnd.sym} -3090 -1700 1 0 {name=l14 lab=GND}
C {lab_pin.sym} -2860 -1760 0 1 {name=p26 lab=Vg+}
C {lab_pin.sym} -2840 -1620 0 1 {name=p27 lab=Vg-}
C {gnd.sym} -2740 -1610 0 0 {name=l17 lab=GND}
C {capa.sym} -2360 -1610 0 0 {name=C8
m=1
value=50p
footprint=1206
device="ceramic capacitor"}
C {gnd.sym} -2360 -1550 0 0 {name=l18 lab=GND}
C {BMR.sym} -2860 -1830 0 0 {name=x6}
C {Gm_C_LPF.sym} -2850 -1660 0 0 {name=x7}
C {gnd.sym} -2430 -1730 3 0 {name=l19 lab=GND}
C {lab_pin.sym} -2600 -1760 0 0 {name=p28 lab=Vg+}
C {lab_pin.sym} -2600 -1640 0 0 {name=p29 lab=Vg-}
C {vsource.sym} -2920 -1620 1 0 {name=V7 value="dc 0" savecurrent=false}
C {lab_pin.sym} -2090 -1810 0 0 {name=p30 lab=Vdd}
C {lab_pin.sym} -2090 -1560 0 0 {name=p31 lab=Vss}
C {lab_pin.sym} -1950 -1650 0 1 {name=p32 lab=Voutb}
C {Gm_C_LPF.sym} -2430 -1640 0 0 {name=x8}
C {gnd.sym} -2010 -1710 3 0 {name=l20 lab=GND}
C {lab_pin.sym} -2180 -1740 0 0 {name=p33 lab=Vg+}
C {lab_pin.sym} -2180 -1620 0 0 {name=p34 lab=Vg-}
C {capa.sym} -2660 -1460 0 0 {name=C9
m=1
value=25p
footprint=1206
device="ceramic capacitor"}
C {gnd.sym} -2660 -1400 0 0 {name=l21 lab=GND}
C {code_shown.sym} -2850 -2680 0 0 {name=s4 only_toplevel=false value="
.lib /foss/pdks/sky130A/libs.tech/combined/sky130.lib.spice tt
.control
  *plot deriv(i(Vmeas)) deriv(i(Vmeas1))
  *tran 1u 2m 
  let vcccp = 0
  let vcccm = 0
  *let vcm = -0.5        
  repeat 10                  
    alter V6 $&vcccp 
    alter V7 $&vcccm
    *alter V2 $&vcm        
    *ac dec 100 0.1 30MEG
    *dc V1 -2.5 2.5 0.01
    tran 1u 5m 
    *plot db(v(Voutb)/(v(Vin+))) xlog title 'Gain BW'
    plot v(Vin+) v(Voutb)
    *plot (180/PI)*phase(v(VoutB)/v(Vin+)) xlog title 'Phase BW'
    *plot deriv(i(Vmeas)) deriv(i(Vmeas1))
    let vcccp = vcccp + 0.025   ; calculate new voltage value for Vcc by updating vector vccc
    let vcccm = vcccm - 0.025   ; calculate new voltage value for Vcc by updating vector vccc
    *let vcm = vcm + 0.1   ; calculate new voltage value for Vcc by updating vector vccc
  end        
  *plot v(VoutA) v(Vin+)
  *plot v(VoutB) v(Vin+)
  *op
  *noise v(VoutB) V1 dec 100 0.1 30MEG
.endc
.end"}
C {simulator_commands.sym} -1360 -2510 0 0 {name=COMMANDS1
simulator=ngspice
only_toplevel=false 
value="
  VGND GND 0 0
  *plot db((v(Vout+)-v(Vout-))/(v(Vin+)-v(Vin-))) xlog title 'Gain OL'
  *plot (180/PI)*phase((v(Vout+)-v(Vout-))/(v(Vin+)-v(Vin-))) xlog title 'Phase OL'
  *plot db((v(Vout+) + v(Vout-))/(2*v(VCM))) xlog title 'Gain OL'
  *plot (180/PI)*phase((v(Vout+) + v(Vout-))/(2*v(VCM))) xlog title 'Phase OL'    
  .tran 1u 20m
  *noise v(Vout+ ,Vout-) V1 dec 100 0.1 1MEG
  .print tran format=raw file=Lock_In_Amplifier.raw v(*) i(*)"}
C {code_shown.sym} -17.5 -2187.5 0 0 {name=OP_AMP_PVT only_toplevel=false value="
.lib /foss/pdks/sky130A/libs.tech/combined/sky130.lib.spice tt
.param ptemp = 27
.param Vsource = 2.5
.options temp = \{ptemp\}
.control
 let T = 0
 let V = 0
 foreach tval -20 100 27
  foreach vval 2.25 2.75 2.5
   save all
   *tran 0.1u 8m
   *dc V1 0 6 0.01
   ac dec 100 0.1 30MEG
   write OP_AMP_TB_AC_TT_PVT.raw
   set appendwrite
   let V = $vval
   alterparam Vsource = $&V
   reset
  end
   let T = $tval
   alterparam ptemp = $&T
   reset
 end
.endc
.end"}
C {code_shown.sym} -837.5 -2377.5 0 0 {name=OPAMPSS only_toplevel=false value="
.lib /foss/pdks/sky130A/libs.tech/combined/sky130.lib.spice ss
.param ptemp = 27
.param Vsource = 2.5
.options temp = \{ptemp\}
.control
 let T = 0
 let V = 0
 foreach tval -20 100 27
  foreach vval 2.25 2.75 2.5
   save all
   *tran 0.1u 8m
   *dc V1 0 6 0.01
   ac dec 100 0.1 30MEG
   write OP_AMP_TB_AC_SS_PVT.raw
   set appendwrite
   let V = $vval
   alterparam Vsource = $&V
   reset
  end
   let T = $tval
   alterparam ptemp = $&T
   reset
 end
.endc
.end"}
C {code_shown.sym} 122.5 -2927.5 0 0 {name=OPAMPOFF only_toplevel=false value="
.lib /foss/pdks/sky130A/libs.tech/combined/sky130.lib.spice tt
.param ptemp = 27
.param Vsource = 2.5
.options temp = \{ptemp\}
.control
 let T = 0
 let V = 0
 foreach tval -20 100 27
  foreach vval 2.25 2.75 2.5
   save all
   tran 0.1u 1m
   *dc V1 0 6 0.01
   *ac dec 100 0.1 30MEG
   write OP_AMP_TB_OFFSET_TT_PVT.raw
   set appendwrite
   let V = $vval
   alterparam Vsource = $&V
   reset
  end
   let T = $tval
   alterparam ptemp = $&T
   reset
 end
.endc
.end"}
C {code_shown.sym} -1327.5 -3497.5 0 0 {name=OPNOISE only_toplevel=false value="
.lib /foss/pdks/sky130A/libs.tech/combined/sky130.lib.spice ff
.param ptemp = 27
.param Vsource = 2.5
.options temp = \{ptemp\}
.control
 let T = 0
 let V = 0
 set wr_vecnames
 *set wr_singlescale
 foreach tval -20 100 27
  foreach vval 2.25 2.75 2.5
   save all
   *tran 1u 2m
   *dc V1 0 6 0.01
   *ac dec 100 0.1 30MEG
   noise v(Vout) V1 dec 100 1 30MEG
   setplot previous
   write OP_AMP_TB_NOISE_FF_PVT.raw
   set appendwrite
   setplot next
   wrdata OP_AMP_TB_INOISE_TOTAL_FF_PVT.txt inoise_total
   wrdata OP_AMP_TB_ONOISE_TOTAL_FF_PVT.txt onoise_total
   *set appendwrite
   let V = $vval
   alterparam Vsource = $&V
   reset
  end
   let T = $tval
   alterparam ptemp = $&T
   reset
 end
.endc
.end"}
C {code_shown.sym} -1650 -2220 0 0 {name=sFDAORIG only_toplevel=false value="
.lib /foss/pdks/sky130A/libs.tech/combined/sky130.lib.spice tt
.control
 *foreach val -0.2m -0.4m -0.6m -0.8m
  save all
  tran 1n 21u 1u
  let V = 'v(Voutp) - v(Voutm)'
  linearize V
  set specwindow = blackman
  fft V
  *let Freq = fourier11[0]
  *let Mag = fourier11[1]
  *noise v(vout+, vout-) V2 dec 100 1 30MEG 
  *dc V2 -2.5 2.5 0.01
  *op
  write FDA_FFT.raw
  *let CM = $val
  *alterparam CM_VAL = $&CM
  set appendwrite
  reset
 *end
.endc
.end"}
C {code_shown.sym} 852.5 -2067.5 0 0 {name=FDA_MEAS only_toplevel=false value="
.lib /foss/pdks/sky130A/libs.tech/combined/sky130.lib.spice ff
.param ptemp = 27
.param Vsource = 2.5
.options temp = \{ptemp\}
.control
 let T = 0
 let V = 0
 set wr_vecnames
 *set wr_singlescale
 foreach tval -20 100 27
  foreach vval 2.25 2.75 2.5
   save all
   *tran 1u 2m
   *dc V1 0 6 0.01
   ac dec 100 0.1 30MEG
   *noise v(Vout) V1 dec 100 1 30MEG
   *setplot previous
   write FDA_TB_AC_DIFF_FF_PVT.raw
   set appendwrite
   **OL GAIN**
   let vdiff = 'v(voutp) + v(outm)'
   meas ac olgain FIND vdiff AT=1 
   let olgaindb = 'db(olgain)'
   wrdata FDA_OL_GAIN_DB_FF_PVT.txt olgaindb
   **UGW**
   meas ac ugw WHEN vdiff=0 FALL=1
   wrdata FDA_OL_UGW_FF_PVT.txt ugw
   **PM**
   let pm = '180 + 180/PI*ph(voutp)'
   meas ac ph FIND pm WHEN vdiff=0 FALL=1
   wrdata FDA_OL_PM_FF_PVT.txt pm
   *setplot next
   *wrdata OP_AMP_TB_ONOISE_TOTAL_SS_PVT.txt onoise_total
   *set appendwrite
   let V = $vval
   alterparam Vsource = $&V
   reset
  end
   let T = $tval
   alterparam ptemp = $&T
   reset
 end
.endc
.end"}
C {code_shown.sym} 1462.5 -2167.5 0 0 {name=FDAFF only_toplevel=false value="
.lib /foss/pdks/sky130A/libs.tech/combined/sky130.lib.spice ff
.param ptemp = 27
.param Vsource = 2.5
.options temp = \{ptemp\}
.control
 let T = 27
 let V = 2.5
 
 let i_count = 9
 let T_vec = vector(i_count)
 let V_vec = vector(i_count)
 let PM_vec = vector(i_count)
 let UGW_vec = vector(i_count)
 let GAIN_vec = vector(i_count)

 let index = 0
 
 set wr_vecnames
 foreach tval -20 100 27
  foreach vval 2.25 2.75 2.5
   save all
   *tran 1u 2m
   *dc V1 0 6 0.01
   ac dec 100 0.1 30MEG
   *noise v(Vout) V1 dec 100 1 30MEG
   *setplot previous
   write FDA_TB_AC_DIFF_FF_PVT.raw
   
   set noprintscale
   **OL GAIN**
   let vdiff = 'v(voutp) - v(voutm)'
   let olgaindb = 'db(vdiff)'
   meas ac olgain MAX olgaindb 
   let GAIN_vec[index] = 'olgain'
   **UGW**
   meas ac ugw WHEN olgaindb=0 FALL=1
   let UGW_vec[index] = 'ugw'
   **PM**
   let pm = '180 + 180/PI*ph(voutp)'
   meas ac ph FIND pm WHEN olgaindb=0 FALL=1
   let PM_vec[index] = 'ph'
   *setplot next
   *wrdata OP_AMP_TB_ONOISE_TOTAL_SS_PVT.txt onoise_total
   
   set appendwrite
   let V_vec[index] = 'V'
   let T_vec[index] = 'T'
   
   echo -n This is $&V
   echo -n This is $&T  

   let V = $vval
   alterparam Vsource = $&V
   reset
   let index = index + 1
  end
   let T = $tval
   alterparam ptemp = $&T
   reset
 end
   print col GAIN_vec UGW_vec PM_vec T_vec V_vec > FDA_AC_GAIN_UGW_PM_FF_PVT.txt
.endc
.end"}
C {vsource.sym} -4982.5 -347.5 0 0 {name=V2 value="dc 0" savecurrent=false}
C {lab_pin.sym} -4982.5 -407.5 0 0 {name=p35 lab=VCM}
C {gnd.sym} -4982.5 -287.5 0 0 {name=l22 lab=GND}
C {lab_pin.sym} -5052.5 -407.5 0 0 {name=p36 lab=VoCM}
C {vsource.sym} -5052.5 -347.5 0 0 {name=V3 value="dc 0 ac 1" savecurrent=false}
C {gnd.sym} -5052.5 -287.5 0 0 {name=l23 lab=GND}
C {vsource.sym} -4872.5 -717.5 0 0 {name=V4 value="dc 0 ac 0" savecurrent=false}
C {vsource.sym} -4872.5 -907.5 0 0 {name=V8 value="dc 0" savecurrent=false}
C {lab_pin.sym} -4872.5 -967.5 0 0 {name=p37 lab=Vin-}
C {lab_pin.sym} -4872.5 -777.5 0 0 {name=p38 lab=Vinp}
C {gnd.sym} -4872.5 -847.5 0 0 {name=l24 lab=GND}
C {gnd.sym} -4872.5 -657.5 0 0 {name=l25 lab=GND}
C {vsource.sym} -4732.5 -627.5 0 0 {name=V9 value="dc \{Vsource\}" savecurrent=false}
C {gnd.sym} -4732.5 -707.5 2 0 {name=l26 lab=GND}
C {vsource.sym} -4732.5 -857.5 0 0 {name=V10 value="dc \{Vsource\}" savecurrent=false}
C {gnd.sym} -4732.5 -787.5 0 0 {name=l27 lab=GND}
C {lab_pin.sym} -4732.5 -937.5 0 0 {name=p39 lab=Vdd}
C {lab_pin.sym} -4732.5 -567.5 0 0 {name=p40 lab=Vss}
C {vsource.sym} -4862.5 -537.5 0 0 {name=V11 value="dc 0" savecurrent=false}
C {lab_pin.sym} -4862.5 -597.5 0 0 {name=p41 lab=PWRDWN}
C {gnd.sym} -4862.5 -477.5 0 0 {name=l28 lab=GND}
C {capa.sym} -4652.5 -627.5 0 0 {name=C10
m=1
value=10u
footprint=1206
device="ceramic capacitor"}
C {capa.sym} -4652.5 -857.5 0 0 {name=C11
m=1
value=10u
footprint=1206
device="ceramic capacitor"}
C {Diff_OP_AMP.sym} -4342.5 -227.5 0 0 {name=x9}
C {lab_pin.sym} -4382.5 -317.5 0 0 {name=p42 lab=Vdd}
C {lab_pin.sym} -4382.5 -137.5 0 0 {name=p43 lab=Vss}
C {lab_pin.sym} -4582.5 -247.5 0 0 {name=p44 lab=Vinp}
C {BMR.sym} -4652.5 -327.5 0 0 {name=x10}
C {lab_pin.sym} -4822.5 -337.5 3 1 {name=p45 lab=Vdd}
C {CMFB.sym} -4062.5 -227.5 0 0 {name=x11}
C {lab_pin.sym} -4062.5 -127.5 2 0 {name=p46 lab=Vss}
C {lab_pin.sym} -4062.5 -327.5 0 1 {name=p47 lab=Vdd}
C {lab_pin.sym} -4192.5 -127.5 2 0 {name=p48 lab=Voutm}
C {lab_pin.sym} -4202.5 -317.5 0 1 {name=p49 lab=Voutp}
C {lab_pin.sym} -3902.5 -197.5 0 1 {name=p50 lab=Vbiasm}
C {lab_pin.sym} -4152.5 -227.5 0 0 {name=p51 lab=VCM}
C {lab_pin.sym} -3902.5 -247.5 0 1 {name=p52 lab=Vbiasp}
C {lab_pin.sym} -4592.5 -207.5 0 0 {name=p53 lab=Vinm}
C {res.sym} -4282.5 -97.5 3 1 {name=R11
value=10k
footprint=1206
device=resistor
m=1}
C {res.sym} -4282.5 -357.5 3 1 {name=R12
value=10k
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} -4832.5 -317.5 3 1 {name=p54 lab=PWRDWN}
C {ind.sym} -4182.5 -257.5 3 1 {name=L29
m=1
value=1T
footprint=1206
device=inductor}
C {ind.sym} -4182.5 -197.5 3 1 {name=L30
m=1
value=1T
footprint=1206
device=inductor}
C {capa.sym} -4182.5 -287.5 1 0 {name=C12
m=1
value=1G
footprint=1206
device="ceramic capacitor"}
C {capa.sym} -4172.5 -157.5 1 1 {name=C13
m=1
value=1G
footprint=1206
device="ceramic capacitor"}
C {capa.sym} -4112.5 -357.5 3 0 {name=C14
m=1
value=1p
footprint=1206
device="ceramic capacitor"}
C {gnd.sym} -4052.5 -357.5 3 1 {name=l31 lab=GND}
C {capa.sym} -4112.5 -97.5 3 0 {name=C15
m=1
value=1p
footprint=1206
device="ceramic capacitor"}
C {gnd.sym} -4052.5 -97.5 3 1 {name=l32 lab=GND}
C {code_shown.sym} -5640 -1195 0 0 {name=s5 only_toplevel=false value="
.lib /foss/pdks/sky130A/libs.tech/combined/sky130.lib.spice tt
.param ptemp = 27
.param Vsource = 2.5
.options temp = \{ptemp\}
.control
 let T = 27
 let V = 2.5
 
 let i_count = 9
 let T_vec = vector(i_count)
 let V_vec = vector(i_count)
 *let PM_vec = vector(i_count)
 *let UGW_vec = vector(i_count)
 *let GAIN_vec = vector(i_count)
 let OFFSET_vec = vector(i_count)

 let index = 0
 
 set wr_vecnames
 foreach tval -20 100 27
  foreach vval 2.25 2.75 2.5
   save all
   tran 1u 2m
   *dc V1 0 6 0.01
   *ac dec 100 0.1 30MEG
   *noise v(Vout) V1 dec 100 1 30MEG
   *setplot previous
   write FDA_TRAN_OFFSETS_TT_PVT.raw
   
   set noprintscale
   **OL GAIN**
   let vdiff = 'v(voutp) - v(voutm)'
   ***let vcom = '(v(voutp) + v(voutm))/2'
   ***let olgaindb = 'db(vcom)'
   ***meas ac olgain MAX olgaindb 
   ***let GAIN_vec[index] = 'olgain'
   **UGW**
   ***meas ac ugw WHEN olgaindb=0 FALL=1
   ***let UGW_vec[index] = 'ugw'
   **PM**
   ***let pm = '180 + 180/PI*ph(voutp)'
   ***let pm_cm = '180/PI*ph(voutp)'
   ***meas ac ph FIND pm_cm WHEN olgaindb=0 FALL=1
   ***let PM_vec[index] = 'ph'
   *setplot next
   *wrdata OP_AMP_TB_ONOISE_TOTAL_SS_PVT.txt onoise_total
   **OFFSET**
   let vidiff = 'v(vinp) - v(vinm)'
   let voff = 'vdiff - vidiff'
   meas tran offsets MAX voff
   let OFFSET_vec[index] = 'offsets' 
   
   set appendwrite
   let V_vec[index] = 'V'
   let T_vec[index] = 'T'
   
   echo -n This is $&V
   echo -n This is $&T  

   let V = $vval
   alterparam Vsource = $&V
   reset
   let index = index + 1
  end
   let T = $tval
   alterparam ptemp = $&T
   reset
 end
  **OL AC
  ** print col GAIN_vec UGW_vec PM_vec T_vec V_vec > FDA_AC_CM_GAIN_UGW_PM_SS_PVT.txt
  **Offset   
     print col OFFSET_vec T_vec V_vec > FDA_OFFSETS_TT_PVT.txt
  

.endc
.end"}
C {lab_pin.sym} -4252.5 -287.5 0 0 {name=p55 lab=VoCM}
C {lab_pin.sym} -4222.5 -157.5 0 0 {name=p56 lab=VoCM}
C {res.sym} -4492.5 -247.5 3 1 {name=R13
value=10k
footprint=1206
device=resistor
m=1}
C {res.sym} -4492.5 -207.5 3 1 {name=R14
value=10k
footprint=1206
device=resistor
m=1}
C {simulator_commands.sym} -4230 -910 0 0 {name=COMMANDS
simulator=xyce
only_toplevel=false 
value="VGND GND 0 0
.PARAM Vsource = 2.5

.tran 0.1u 5m
.step Vsource list 2.5 2.25 2.75 
.step TEMP list 27 -20 100

.OPTIONS MEASPRINT = STDOUT

.MEASURE TRAN CLK_SLEW_RISE_SS TRIG V(vclk1)=\{-0.9*Vsource\} RISE = LAST 
+TARG V(vclk1)=\{0.9*Vsource\} RISE = LAST 

.MEASURE TRAN CLK_SLEW_FALL_SS TRIG V(vclk1)=\{0.9*Vsource\} FALL = LAST 
+TARG V(vclk1)=\{-0.9*Vsource\} FALL = LAST 

.result \{CLK_SLEW_RISE_SS\}
.result \{CLK_SLEW_FALL_SS\}

.print tran format=raw file=CLK_TB_SS.raw v(*) i(*)
 "}
C {simulator_commands.sym} -4240 -700 0 0 {name=COMMANDS2
simulator=xyce
only_toplevel=false 
value="VGND GND 0 0
.PARAM Vsource = 2.5

.tran 0.01u 5m
.step Vsource list 2.5 2.25 2.75 
.step TEMP list 27 -20 100

.OPTIONS MEASPRINT = STDOUT

.MEASURE TRAN CLK_SKEW_RISE_SS TRIG V(vclk1)=0 RISE = LAST 
+TARG V(vclk2)=0 RISE = LAST 

.MEASURE TRAN CLK_SKEW_FALL_SS TRIG V(vclk1)=0 FALL = LAST 
+TARG V(vclk2)=0 FALL = LAST 

.result \{CLK_SKEW_RISE_SS\}
.result \{CLK_SKEW_FALL_SS\}

.print tran format=raw file=CLK_TB_SS.raw v(*) i(*)
 "}
C {code_shown.sym} -3860 -3040 0 0 {name=s6 only_toplevel=false value="
.lib /foss/pdks/sky130A/libs.tech/combined/sky130.lib.spice tt
.param ptemp = 27
.param Vsource = 2.5
.options temp = \{ptemp\}
.control
 let T = 27
 let V = 2.5
 
 let i_count = 9
 let T_vec = vector(i_count)
 let V_vec = vector(i_count)
 *let CUTOFF_vec = vector(i_count)
 let OFFSET_vec = vector(i_count)
 *let INOISE_total_vec = vector(i_count)
 *let ONOISE_total_vec = vector(i_count)

 let index = 0
 
 set wr_vecnames
 foreach tval -20 100 27
  foreach vval 2.25 2.75 2.5
   save all
   *tran 1u 20m
   dc V1 -2.5 2.5 0.1
   *ac dec 100 0.1 30MEG
   *noise v(Voutb) V1 dec 100 1 2.5MEG
   *setplot previous
   write GMC_REDO_05_OFFSET_TT_PVT.raw
   
   set noprintscale
   **OL GAIN**
    ***let gaindb = 'db(voutb/vin)'
    ***meas ac maxgain MAX gaindb 
    ***let cutoffdb = 'maxgain - 3'
    ***meas ac cutoff_freq WHEN gaindb = cutoffdb
    ***let CUTOFF_vec[index] = 'cutoff_freq' 
   **UGW**
   ***meas ac ugw WHEN olgaindb=0 FALL=1
   ***let UGW_vec[index] = 'ugw'
   **PM**
   ***let pm = '180 + 180/PI*ph(voutp)'
   ***let pm_cm = '180/PI*ph(voutp)'
   ***meas ac ph FIND pm_cm WHEN olgaindb=0 FALL=1
   ***let PM_vec[index] = 'ph'
   ***setplot next
   ***wrdata GMC_TB_ONOISE_TOTAL_TT_PVT.txt onoise_total
   **OFFSET**
   ***let vidiff = 'v(vinp) - v(vinm)'
   ***let voff = 'vdiff - vidiff'
    meas dc offsets FIND v(voutb) WHEN v(vin) = 0 RISE = 1
    let OFFSET_vec[index] = 'offsets' 
   **NOISE**
   ***setplot next
   ***let inoise = 'inoise_total'
   ***let onoise = 'onoise_total'
   
   ***let INOISE_total_vec[index] = 'inoise'
   ***let ONOISE_total_vec[index] = 'onoise'
  
  

   set appendwrite
   let V_vec[index] = 'V'
   let T_vec[index] = 'T'
   
   echo -n This is $&V
   echo -n This is $&T  

   let V = $vval
   alterparam Vsource = $&V
   reset
   let index = index + 1
  end
   let T = $tval
   alterparam ptemp = $&T
   reset
 end
  **OL AC
   ***print col CUTOFF_vec T_vec V_vec > GM_REDO_AC_06_CUTOFF_SS_PVT.txt
  **Offset   
    ***print col OFFSET_vec T_vec V_vec > GMC_REDO_OFFSETS_05_TT_PVT.txt
  **NOISE   
  ***print col INOISE_total_vec ONOISE_total_vec T_vec V_vec > GMC_NOISE05_TT_PVT.txt
  

.endc
.end"}
C {code_shown.sym} -4737.5 2.5 0 0 {name=s7 only_toplevel=false value="
.lib /foss/pdks/sky130A/libs.tech/combined/sky130.lib.spice ss_mm

***Centered at 40C and varies to a range of -20 to 100; with 20C being 1-standard dev***
.param TEMPGAUSS = agauss(40, 60, 3)

***Centered at 2.5V and varies to a range of 2V to 3V; with 0.16mV being 1-standard dev***
.param VOLTGAUSS = agauss(2.5, 0.5, 3)

.param ptemp = 'TEMPGAUSS'

.param Vsource = 'VOLTGAUSS'
.options temp = \{ptemp\}

.csparam ctemp = \{ptemp\}
.csparam cvolt = \{Vsource\}


.control
 let T = 27
 let V = 2.5
 
 let i_count = 100
 let T_vec = vector(i_count)
 let V_vec = vector(i_count)
 
 let OFFSETP_vec = vector(i_count)
 let OFFSETM_vec = vector(i_count)
 let OFFSETCM_vec = vector(i_count)
 let OFFSETDIF_vec = vector(i_count)
 let OFFSETMIX_vec = vector(i_count)
 let OFFSETOUT_vec = vector(i_count)

 let index = 0
 
 set wr_vecnames
 dowhile index <= 100
   save all
   tran 1u 2m
   *dc V1 0 6 0.01
   *ac dec 100 0.1 30MEG
  
   write PRE_LPF_OFFSETS_SS_MM_PVT.raw
   
   set noprintscale
   
   **OFFSET**

 
    let vodiff = 'v(voutp) - v(voutm)'
    let vmixdiff = 'v(MIXOUTP) - v(MIXOUTM)'
    ***let voff = 'vdiff - vidiff'
   
   meas tran Offp AVG v(voutp) FROM= 1m TO = 2m
   meas tran Offm AVG v(voutm) FROM= 1m TO = 2m
   meas tran Offdif AVG vodiff FROM= 1m TO = 2m
   meas tran Offmix AVG vmixdiff FROM= 1m TO = 2m
   meas tran Offout AVG v(DIFFOUT) FROM= 1m TO = 2m
    
   let OFFSETP_vec[index] = 'Offp' 
   let OFFSETM_vec[index] = 'Offm' 
   let OFFSETCM_vec[index] = '(Offp + Offm)/2' 
   let OFFSETDIF_vec[index] = 'Offdif'
   let OFFSETMIX_vec[index] = 'Offmix'
   let OFFSETOUT_vec[index] = 'Offout'
   

   set appendwrite  
     

   let V = $&cvolt
   let T = $&ctemp

   echo -n This is $&V
   echo -n This is $&T
   echo -n This is $&index

   let V_vec[index] = 'V'
   let T_vec[index] = 'T'
   
   let index = index + 1
   reset
 end
  **OL AC
  *** print col GAIN_vec UGW_vec PM_vec T_vec V_vec > FDA_AC_CM_GAIN_UGW_PM_SS_PVT.txt
  **Offset   
   print col OFFSETDIF_vec OFFSETMIX_vec OFFSETOUT_vec T_vec V_vec > PRE_LPF_OFFSETS_SS_MM_PVT.txt
    
.endc
.end"}
C {code_shown.sym} -3380 180 0 0 {name=s8 only_toplevel=false value="
.lib /foss/pdks/sky130A/libs.tech/combined/sky130.lib.spice tt
.param ptemp = 27
.param Vsource = 2.5
.options temp = \{ptemp\}
.control
 let T = 27
 let V = 2.5
 
 let i_count = 9
 let T_vec = vector(i_count)
 let V_vec = vector(i_count)
 *let CUTOFF_vec = vector(i_count)
 *let OFFSET_vec = vector(i_count)
 *let INOISE_total_vec = vector(i_count)
 *let ONOISE_total_vec = vector(i_count)

 let index = 0
 
 set wr_vecnames
 foreach tval -20 100 27
  foreach vval 2.25 2.75 2.5
   save all
   tran 1u 20m
   *dc V1 -20m 20m 1m
   *ac dec 100 0.1 30MEG
   *noise v(Voutb) V1 dec 100 1 2.5MEG
   *setplot previous
   write GMC_REDO_TRAN_TT_PVT.raw
   
   set noprintscale
   **OL GAIN**
     ***let gaindb = 'db(voutb/vin)'
     ***meas ac maxgain MAX gaindb 
     ***let cutoffdb = 'maxgain - 3'
     ***meas ac cutoff_freq WHEN gaindb = cutoffdb
     ***let CUTOFF_vec[index] = 'cutoff_freq' 
   **UGW**
   ***meas ac ugw WHEN olgaindb=0 FALL=1
   ***let UGW_vec[index] = 'ugw'
   **PM**
   ***let pm = '180 + 180/PI*ph(voutp)'
   ***let pm_cm = '180/PI*ph(voutp)'
   ***meas ac ph FIND pm_cm WHEN olgaindb=0 FALL=1
   ***let PM_vec[index] = 'ph'
   ***setplot next
   ***wrdata GMC_TB_ONOISE_TOTAL_TT_PVT.txt onoise_total
   **OFFSET**
   ***let vidiff = 'v(vinp) - v(vinm)'
   ***let voff = 'vdiff - vidiff'
   ***meas dc offsets FIND v(voutb) WHEN v(vin) = 0 RISE = 1
   ***let OFFSET_vec[index] = 'offsets' 
   **NOISE**
    *** setplot next
    *** let inoise = 'inoise_total'
    *** let onoise = 'onoise_total'
   
    *** let INOISE_total_vec[index] = 'inoise'
    *** let ONOISE_total_vec[index] = 'onoise'
  
  

   set appendwrite
   let V_vec[index] = 'V'
   let T_vec[index] = 'T'
   
   echo -n This is $&V
   echo -n This is $&T  

   let V = $vval
   alterparam Vsource = $&V
   reset
   let index = index + 1
  end
   let T = $tval
   alterparam ptemp = $&T
   reset
 end
  **OL AC
   *** print col CUTOFF_vec T_vec V_vec > GM_REDO_AC_04_CUTOFF_SS_PVT.txt
  **Offset   
   *** print col OFFSET_vec T_vec V_vec > GMC_REDO_OFFSETS_04_SS_PVT.txt
  **NOISE   
   ***print col INOISE_total_vec ONOISE_total_vec T_vec V_vec > GMC_REDO_NOISE04_SS_PVT.txt
  

.endc
.end"}
C {code_shown.sym} -5520 470 0 0 {name=s9 only_toplevel=false value="
.lib /foss/pdks/sky130A/libs.tech/combined/sky130.lib.spice tt
.param ptemp = 27
.param Vsource = 2.5
.options temp = \{ptemp\}
.control
 let T = 27
 let V = 2.5
 
 let i_count = 9
 let T_vec = vector(i_count)
 let V_vec = vector(i_count)
 *let CUTOFF_vec = vector(i_count)
 *let OFFSET_vec = vector(i_count)
 *let INOISE_total_vec = vector(i_count)
 *let ONOISE_total_vec = vector(i_count)

 let index = 0
 
 set wr_vecnames
 foreach tval -20 100 27
  foreach vval 2.25 2.75 2.5
   save all
   tran 1u 20m
   *dc V1 -20m 20m 1m
   *ac dec 100 0.1 30MEG
   *noise v(Voutb) V1 dec 100 1 2.5MEG
   *setplot previous
   write GMC_REDO_TRAN_TT_PVT.raw
   
   set noprintscale
   **OL GAIN**
     ***let gaindb = 'db(voutb/vin)'
     ***meas ac maxgain MAX gaindb 
     ***let cutoffdb = 'maxgain - 3'
     ***meas ac cutoff_freq WHEN gaindb = cutoffdb
     ***let CUTOFF_vec[index] = 'cutoff_freq' 
   **UGW**
   ***meas ac ugw WHEN olgaindb=0 FALL=1
   ***let UGW_vec[index] = 'ugw'
   **PM**
   ***let pm = '180 + 180/PI*ph(voutp)'
   ***let pm_cm = '180/PI*ph(voutp)'
   ***meas ac ph FIND pm_cm WHEN olgaindb=0 FALL=1
   ***let PM_vec[index] = 'ph'
   ***setplot next
   ***wrdata GMC_TB_ONOISE_TOTAL_TT_PVT.txt onoise_total
   **OFFSET**
   ***let vidiff = 'v(vinp) - v(vinm)'
   ***let voff = 'vdiff - vidiff'
   ***meas dc offsets FIND v(voutb) WHEN v(vin) = 0 RISE = 1
   ***let OFFSET_vec[index] = 'offsets' 
   **NOISE**
    *** setplot next
    *** let inoise = 'inoise_total'
    *** let onoise = 'onoise_total'
   
    *** let INOISE_total_vec[index] = 'inoise'
    *** let ONOISE_total_vec[index] = 'onoise'
  
  

   set appendwrite
   let V_vec[index] = 'V'
   let T_vec[index] = 'T'
   
   echo -n This is $&V
   echo -n This is $&T  

   let V = $vval
   alterparam Vsource = $&V
   reset
   let index = index + 1
  end
   let T = $tval
   alterparam ptemp = $&T
   reset
 end
  **OL AC
   *** print col CUTOFF_vec T_vec V_vec > GM_REDO_AC_04_CUTOFF_SS_PVT.txt
  **Offset   
   *** print col OFFSET_vec T_vec V_vec > GMC_REDO_OFFSETS_04_SS_PVT.txt
  **NOISE   
   ***print col INOISE_total_vec ONOISE_total_vec T_vec V_vec > GMC_REDO_NOISE04_SS_PVT.txt
  

.endc
.end"}
C {simulator_commands.sym} -1870 -2480 0 0 {name=COMMANDS_FFT
simulator=ngspice
only_toplevel=false 
value="
.lib /foss/pdks/sky130A/libs.tech/combined/sky130.lib.spice tt
.options method = trap
.options rshunt = 1e12
.options retol = 0.01
.options vntol = 10u
.options abstol = 1n
.options trtol = 10
.options chgtol = 1e-10

.options sparse
.control
 save all
 tran 1u 50m 0 100u
 
 let VIN_MIX = 'v(Voutp) - v(Voutm)'
 let VOUT_MIX = 'v(MIXOUTP)-v(MIXOUTM)'
 let DIFF_FFT = 'v(DIFFOUT)'
 let GMOUT_FFT = 'v(GMCOUT)'
 let OUT_FFT = 'v(VOUTPUT)'

 write Lock_In_Amplifier_TB_TT_NOISY_10UV_FFT_NGSPICE.raw
 ***write Lock_In_Amplifier_TB_TT_1MV_IDEAL_NGSPICE.raw

 setplot tran1
 linearize VIN_MIX
 set specwindow = hanning
 fft VIN_MIX
 write Lock_In_Amplifier_NOISY_OUTPUTS_10UV_FFT_NGSPICE.raw

 set appendwrite
 setplot tran1
 linearize VOUT_MIX
 set specwindow = hanning
 fft VOUT_MIX
 write Lock_In_Amplifier_NOISY_OUTPUTS_10UV_FFT_NGSPICE.raw


 set appendwrite
 setplot tran1
 linearize DIFF_FFT
 set specwindow = hanning
 fft DIFF_FFT
 write Lock_In_Amplifier_NOISY_OUTPUTS_10UV_FFT_NGSPICE.raw


 set appendwrite
 setplot tran1
 linearize GMOUT_FFT
 set specwindow = hanning
 fft GMOUT_FFT
 write Lock_In_Amplifier_NOISY_OUTPUTS_10UV_FFT_NGSPICE.raw


 set appendwrite
 setplot tran1
 linearize OUT_FFT
 set specwindow = hanning
 fft OUT_FFT
 write Lock_In_Amplifier_NOISY_OUTPUTS_10UV_FFT_NGSPICE.raw


 set appendwrite 
.endc
.end"}
